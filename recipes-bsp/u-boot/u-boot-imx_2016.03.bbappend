# Copyright (C) 2016 Freescale Semiconductor
# Released under the MIT license (see COPYING.MIT for the terms)

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRCBRANCH = "scm-imx_v2016.03_4.1.15_2.0.0_ga"
SRCREV = "c02a33f177c57b20ba36508d2c830c9f7ea8616a"

COMPATIBLE_MACHINE = "(mx6)"
